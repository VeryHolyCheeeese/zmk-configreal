## boards/shields/baller/Kconfig.defconfig
```kconfig
if SHIELD_BALLER

config ZMK_KEYBOARD_NAME
    default "baller"

endif # SHIELD_BALLER
```
